# Keil uVision project OLED.uvprojx, settings and files
target OLED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\OLED;..\FWLIB\inc;..\HARDWARE\VOICE;..\HARDWARE\RTC;..\USMART;..\HARDWARE\SDIO;..\HARDWARE\SRAM;..\MALLOC;..\HARDWARE\KEY;..\ATK-ESP8266;..\HARDWARE\USART3;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/VOICE/: voice.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_fsmc.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_sdio.c
  group README
    ../: readme.txt
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALLOC
    ../MALLOC/: malloc.c
  group ATK-ESP8266
    ../ATK-ESP8266/: common.c
    ./: wifi_sta.c
